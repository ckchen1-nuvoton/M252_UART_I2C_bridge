# Keil uVision project I2C_Slave.uvprojx, settings and files
target I2C_Loopback (6240000::V6.24::ARMCLANG)
  device: M252KG6AE Nuvoton
  pack: Nuvoton.NuMicroM23_DFP.1.0.6
  cpu: IRAM(0x20000000,0x8000) IROM(0x00000000,0x40000) CPUTYPE("Cortex-M23") CLOCK(12000000) IROM2(0x00100000,0x1000)
  output: I2C_Loopback
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c misc: -Wconditional-uninitialized
  c include: ..\..\..\..\Library\CMSIS\Core\Include;..\..\..\..\Library\Device\Nuvoton\M251\Include;..\..\..\..\Library\StdDriver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT5: ROM 0x100000 size 0x1000
  memory RVCT9: RAM 0x20000000 size 0x8000
  scatter file: ..\..\..\..\Library\Device\Nuvoton\M251\Source\ARM\APROM.scf
  group CMSIS
    ../../../../Library/Device/Nuvoton/M251/Source/: system_M251.c
    ../../../../Library/Device/Nuvoton/M251/Source/ARM/: startup_M251.c
  group Source
    ../: main.c
  group Library
    ../../../../Library/StdDriver/src/: uart.c clk.c i2c.c retarget.c sys.c gpio.c
